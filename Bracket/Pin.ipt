# Autodesk Inventor part: Pin
## iProperties
Created: 2006-11
Part Number: Pin
Document SubType Name: Modeling
Designer: nfjf
Author: nfjf
## Feature names
1. Revolution1
