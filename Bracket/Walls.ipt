# Autodesk Inventor part: Walls
## iProperties
Created: 2006-11
Part Number: Walls
Document SubType Name: Modeling
Designer: nfjf
Author: nfjf
## Feature names
1. Extrusion1
