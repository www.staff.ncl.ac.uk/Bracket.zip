# Autodesk Inventor part: Washer
## iProperties
Created: 2006-11
Part Number: Washer
Document SubType Name: Modeling
Designer: nfjf
Author: nfjf
## Feature names
1. Extrusion1
